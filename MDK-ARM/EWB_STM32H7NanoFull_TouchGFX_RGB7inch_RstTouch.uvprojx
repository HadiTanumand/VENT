# Keil uVision project EWB_STM32H7NanoFull_TouchGFX_RGB7inch_RstTouch.uvprojx, settings and files
target EWB_STM32H7NanoFull_TouchGFX_RGB7inch_RstTouch (6130001::V6.13.1::.\ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: EWB_STM32H7NanoFull_TouchGFX_RGB7inch_RstTouch +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Hardware/W25Q256FV;../Hardware/dwt_stm32_delay;../Hardware/XPT2046;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\OBJ\EWB-STM32H743.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: touch_800x480.c touch_iic.c main.c gpio.c crc.c dma2d.c fmc.c ltdc.c quadspi.c rtc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Hardware
    ../Hardware/W25Q256FV/: W25Q256FV_QSPI.c
    ../Hardware/dwt_stm32_delay/: dwt_stm32_delay.c
  group gui
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen_screen/: screenpresenter.cpp screenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_agencyr_ttf_16_4bpp_0.cpp font_agencyr_ttf_20_4bpp_0.cpp font_dubai_bold_ttf_20_4bpp_0.cpp font_dubai_bold_ttf_20_4bpp_31.cpp font_dubai_bold_ttf_26_4bpp_0.cpp font_dubai_bold_ttf_26_4bpp_31.cpp font_dubai_bold_ttf_30_4bpp_0.cpp font_dubai_light_ttf_20_4bpp_0.cpp font_verdana_10_4bpp_0.cpp font_verdana_40_4bpp_0.cpp font_verdanab_12_4bpp_0.cpp font_verdanab_16_4bpp_0.cpp font_verdanab_20_4bpp_0.cpp font_verdanab_25_4bpp_0.cpp font_verdanab_30_4bpp_0.cpp font_verdanab_34_4bpp_0.cpp font_verdanab_36_4bpp_0.cpp font_verdanab_40_4bpp_0.cpp font_verdanai_20_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_agencyr_ttf_16_4bpp.cpp kerning_agencyr_ttf_20_4bpp.cpp kerning_dubai_bold_ttf_20_4bpp.cpp kerning_dubai_bold_ttf_26_4bpp.cpp kerning_dubai_bold_ttf_30_4bpp.cpp kerning_dubai_light_ttf_20_4bpp.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_verdanab_12_4bpp.cpp kerning_verdanab_16_4bpp.cpp kerning_verdanab_20_4bpp.cpp kerning_verdanab_25_4bpp.cpp kerning_verdanab_30_4bpp.cpp kerning_verdanab_34_4bpp.cpp kerning_verdanab_36_4bpp.cpp kerning_verdanab_40_4bpp.cpp kerning_verdanai_20_4bpp.cpp table_agencyr_ttf_16_4bpp.cpp table_agencyr_ttf_20_4bpp.cpp table_dubai_bold_ttf_20_4bpp.cpp table_dubai_bold_ttf_26_4bpp.cpp table_dubai_bold_ttf_30_4bpp.cpp table_dubai_light_ttf_20_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_40_4bpp.cpp table_verdanab_12_4bpp.cpp table_verdanab_16_4bpp.cpp table_verdanab_20_4bpp.cpp table_verdanab_25_4bpp.cpp table_verdanab_30_4bpp.cpp table_verdanab_34_4bpp.cpp table_verdanab_36_4bpp.cpp table_verdanab_40_4bpp.cpp table_verdanai_20_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_activealarmbutton.cpp image_add.cpp image_adult.cpp image_adult_2.cpp image_adultbtn_1.cpp image_air.cpp image_alarm.cpp image_alarm_big.cpp image_alarm_bigred.cpp image_alarm_bigyellow.cpp image_alarm_red.cpp image_alarm_yellow.cpp image_alertwindow.cpp image_arbcancel-ressed.cpp image_arbcancel.cpp image_arbstartvent-pressed.cpp image_arbstartvent.cpp image_arbstoppedvent-pressed.cpp image_arbstoppedvent.cpp image_arbyes-pressed.cpp image_arbyes.cpp image_arrow.cpp image_arrowguide_l.cpp image_arrowguide_r.cpp image_audio_fill.cpp image_audio_fillbg.cpp image_audio_high.cpp image_audio_indicator.cpp image_audio_low.cpp image_autooff.cpp image_autoon.cpp image_autoscale.cpp image_autoscale_pressed.cpp image_back2.cpp image_back_datagraphs.cpp image_backbutton_bigger.cpp image_battery_left.cpp image_bigcircuit.cpp image_blockinghand.cpp image_boltwhite.cpp image_bright_high.cpp image_bright_low.cpp image_button2gray.cpp image_button2gray_pressed.cpp image_button_1-pressed.cpp image_button_1.cpp image_button_2-pressed.cpp image_button_2.cpp image_button_alarms.cpp image_button_g.cpp image_buttonblue2.cpp image_buttonblue2_pressed.cpp image_cancelbutton-pressed.cpp image_cancelbutton.cpp image_child.cpp image_choose1.cpp image_choose4.cpp image_choose5.cpp image_choose_toggle.cpp image_chooseback.cpp image_choosecircle.cpp image_chooselong.cpp image_chooselong2.cpp image_choosenext.cpp image_chooseradiobutton.cpp image_choosesmall.cpp image_choosestart.cpp image_circuit1.cpp image_cross_image_2.cpp image_cryonbutton.cpp image_cryonbutton_pressed.cpp image_duallimb.cpp image_duallimb_small.cpp image_flowsensor.cpp image_flowsensor_flip.cpp image_good.cpp image_hand_natural.cpp image_invasive-small.cpp image_invasive.cpp image_invasive_3.cpp image_languagebg.cpp image_loading.cpp image_lock.cpp image_long_button.cpp image_long_button_press.cpp image_longbutton2.cpp image_longbuttonblue.cpp image_longbuttonblue2.cpp image_longbuttonblue2_pressed.cpp image_longbuttonblue_pressed.cpp image_mask-small.cpp image_masktype.cpp image_monitor_darkblue.cpp image_monitor_grey.cpp image_monitoring.cpp image_monitoring_4.cpp image_monitoring_pressed.cpp image_monitoringblue.cpp image_monitoringblue_pressed.cpp image_mutealarm.cpp image_next.cpp image_next2x.cpp image_next2x_pressed.cpp image_next_pressed.cpp image_nextpagebutton.cpp image_no_file.cpp image_notgood.cpp image_okbutton-pressed.cpp image_okbutton.cpp image_options_darkblue.cpp image_options_grey.cpp image_paramed.cpp image_pediatricbtn.cpp image_pressurebar.cpp image_previous.cpp image_previous2x.cpp image_previous2x_pressed.cpp image_previous_pressed.cpp image_radiobtn_select.cpp image_radiobtn_trends.cpp image_radiobtn_unselect.cpp image_radiobtn_unselectpressed.cpp image_radiobtnselected_xl.cpp image_radiobtnu_xl.cpp image_radiobtnup_xl.cpp image_selector2.cpp image_selector3.cpp image_selectorlong2.cpp image_selectorsmall.cpp image_settingblue.cpp image_settingblue_pressed.cpp image_settingh-pressed_1.cpp image_settingh.cpp image_settingh_1.cpp image_settingh_pressed.cpp image_settings.cpp image_silent.cpp image_single_leack.cpp image_singlecircuitb.cpp image_singlecircuitsmall.cpp image_singleleak_small.cpp image_smallcircuit.cpp image_startvent.cpp image_startventpress.cpp image_stopvent.cpp image_stopventpress.cpp image_toggle_off.cpp image_toggle_on.cpp image_trigevent.cpp image_twincircuit.cpp image_unlock.cpp image_vent.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__designer/: image_blue_progressindicators_bg_large_progress_indicator_bg_square_0_degrees.cpp image_dark_buttons_square_small.cpp image_dark_buttons_square_small_pressed.cpp
    ../touchgfx/generated/texts/src/: languagearb.cpp languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen_screen/: screenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil6.x/: touchgfx_core_wchar16.lib
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 5.3.0
